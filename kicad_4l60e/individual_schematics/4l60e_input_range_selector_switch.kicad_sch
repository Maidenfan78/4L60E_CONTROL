File: kicad_4l60e/individual_schematics/4l60e_input_range_selector_switch.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: updates
Other:
- moved on the sheet: R1, R2, R3, R4
